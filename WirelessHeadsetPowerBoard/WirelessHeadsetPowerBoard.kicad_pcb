# Repository commanderluka/WirelessHeadsetPowerSystem

## KiCad design WirelessHeadsetPowerBoard/WirelessHeadsetPowerBoard.kicad_pcb

Parts:
C1, C3, C11: 6.8nF 50V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C2, C4, C12: 100nF 50V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C5, C6: 82nF 50V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C7, C10: 22nF 50V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C8: 1nF 50V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C9, C16, C17: 10nF 50V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C13: 2.2pF 50V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C14, C15: 22uF 50V; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1: D_Schottky; D_SOD-123
D2, D3, D4: LED; LED_Kingbright_APFA3010_3x1.5mm_Horizontal
J1: Conn_01x02_Male; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J2: Barrel_Jack_MountingPin; BarrelJack_Wuerth_6941xx301002
J3: Conn_01x02_Female; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
R1, R2: 1; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3, R15, R16: 510; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4, R6: 15K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5: 27K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R7: 1.8K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R8, R13: 390K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R9: 130K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R10: 1M; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R11: 43K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R12: 47K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R14: 180K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: NXQ1TXH5_101J; QFN50P500X500X85-33N; PARTREV 1.1
Y1: 32.768 kHz Crystal; Crystal_SMD_MicroCrystal_CC7V-T1A-2Pin_3.2x1.5mm_HandSolder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

Connections:
+5V: C14.1, C15.1, C16.1, C17.1, J2.1, R3.2, R8.1, R10.1, R15.2, R16.2, U1.15 (VDDP2), U1.16 (VDDP2), U1.25 (VDDP1), U1.26 (VDDP1)
A_Sense: C9.1, C10.1, R10.2, R14.1, U1.10 (ASEN1), U1.13 (ASEN2)
Coil_In: J1.2, R2.1, U1.23 (OUT1), U1.24 (OUT1)
Coil_Out: C2.2, C4.2, C5.2, C6.2, R1.1, U1.17 (OUT2), U1.18 (OUT2)
GND: C1.2, C3.2, C7.2, C8.2, C10.2, C11.2, C12.2, C14.2, C15.2, C16.2, C17.2, D2.1 (K), J2.2, J2.MP (MountPin), R6.2, R7.2, R14.2, U1.12 (NTC), U1.14 (STBY), U1.19 (GNDP), U1.20 (GNDP), U1.21 (GNDP), U1.22 (GNDP), U1.27 (GNDD), U1.31 (TEST), U1.33 (GND)
unnamed: C1.1, R1.2
unnamed: C2.1, C4.1, C5.1, C6.1, D1.2 (A), J1.1
unnamed: C3.1, R2.2
unnamed: C7.1, D1.1 (K), R4.1, R5.1
unnamed: C8.1, R8.2, R9.1, R11.1, R12.1, R13.1, U1.9 (CNF_IN)
unnamed: C9.2, R4.2, R6.1
unnamed: C12.1, U1.28 (CDEC)
unnamed: C13.1, U1.29 (XTAL_IN)
unnamed: C13.2, Y1.1
unnamed: D2.2 (A), R3.1
unnamed: D3.1 (K), U1.8 (LED_R)
unnamed: D3.2 (A), R15.1
unnamed: D4.1 (K), U1.7 (LED_G)
unnamed: D4.2 (A), R16.1
unnamed: J3.1, U1.3 (SDA)
unnamed: J3.2, U1.4 (SCL)
unnamed: R9.2, U1.6 (CNF4)
unnamed: R11.2, U1.2 (CNF3)
unnamed: R12.2, U1.1 (CNF2)
unnamed: R13.2, U1.32 (CNF1)
unnamed: U1.30 (XTAL_OUT), Y1.2
V_Sense: C11.1, R5.2, R7.1, U1.11 (VSEN)

Notes on the sheet:
Green
Red
Wireless Charging Transmitter
Power Input
Charging Coil Filter
Charge Control IC
Blue

Board: 2 copper layers, 44.4 x 63.5 mm, 42 parts (0 on the bottom side), 27 nets.

## Commit log

2021-02-18 finished layout
2021-03-05 made changes, made gerbs, winning
